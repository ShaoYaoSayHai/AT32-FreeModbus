# Keil uVision project AT32F403ACGU7_PTP.uvprojx, settings and files
target AT32F403ACGU7_PTP (6120000::V6.12::.\ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACGU7_PTP +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\user\configs;..\..\user\drivers;..\..\user\applications;..\..\user\bases
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_debug.c wk_usart.c wk_gpio.c rtc.c wk_tmr.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_xmc.c at32f403a_407_emac.c at32f403a_407_sdio.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group configs
    ../../user/configs/: base_config.h elec_config.h uart_config.h
  group drivers
    ../../user/drivers/: drv_uart.c drv_led.c
  group applications
    ../../user/applications/: tch_uart.c mb_rtu.c
